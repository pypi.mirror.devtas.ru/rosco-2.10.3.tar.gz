! Test input parameters for IceFloe
!
!  Model selection and general inputs
!
timeStep           0.1
duration           600.0
randomSeed         123
!
!  General ice property inputs
!
iceThickness       1.0
iceVelocity        0.20
iceDirection       0.0
refIceStrength     2200000.0
!
!  Tower configuration inputs
!
towerDiameter      6.0
numLegs            1.0
towerFrequency     0.28
!
!  Inputs for lock-in crushing
!
iceType            4
shapeFactor_k1     0.900000
contactFactor_k2   0.500000
